#include <stdio.h>

int main(void)
{
	int i, j;
	int a[3][3] = { {1,2,3},{4,5,6},{7,8,9} }, b[3][3] = { {1,2,3},{4,5,6},{7,8,9} }, c[3][3] = { {0,0,0},{0,0,0},{0,0,0} };

	printf("a + b \n");
	for (i = 0; i < 3; i++)
	{
		for (j = 0; j < 3; j++)
		{
			c[i][j] = a[i][j] + b[i][j];
			printf(" %3d", c[i][j]);
		}printf("\n");
	}
	printf("*****************************************************************************\n\n");

	int D[3][3], C[3][3] = { {0,0,0},{0,0,0},{0,0,0} };

	printf("determinant A\n\n");

	for (i = 0; i < 3; i++)
	{
		for (j = 0; j < 3; j++)
		{
			printf("%3d", a[i][j]);
		}printf("\n");
	}
	D[3][3] = a[0][0] * a[1][1] * a[2][2] + a[1][0] * a[2][1] * a[0][2] + a[2][0] * a[1][2] * a[0][1] - a[2][0] * a[1][1] * a[0][2] - a[1][0] * a[0][1] * a[2][2] - a[0][0] * a[1][2] * a[2][1];
	printf("determinant A = %d\n\n", D[3][3]);

	printf("*****************************************************************************\n\n");

	printf(" C = A * B\n\n");

	C[0][0] = a[0][0] * b[0][0] + a[0][1] * b[1][0] + a[0][2] * b[2][0];
	C[0][1] = a[0][0] * b[0][1] + a[0][1] * b[1][1] + a[0][2] * b[2][1];
	C[0][2] = a[0][0] * b[0][2] + a[0][1] * b[1][2] + a[0][2] * b[2][2];
	C[1][0] = a[1][0] * b[0][0] + a[1][1] * b[1][0] + a[1][2] * b[2][0];
	C[1][1] = a[1][0] * b[0][1] + a[1][1] * b[1][1] + a[1][2] * b[2][1];
	C[1][2] = a[1][0] * b[0][2] + a[1][1] * b[1][2] + a[1][2] * b[2][2];
	C[2][0] = a[2][0] * b[0][0] + a[2][1] * b[1][0] + a[2][2] * b[2][0];
	C[2][1] = a[2][0] * b[0][1] + a[2][1] * b[1][1] + a[2][2] * b[2][1];
	C[2][2] = a[2][0] * b[0][2] + a[2][1] * b[1][2] + a[2][2] * b[2][2];

	for (i = 0; i < 3; i++)
	{
		for (j = 0; j < 3; j++)
		{
			printf("%3d ", C[i][j]);
		}printf("\n");
	}
}

